# Autodesk Inventor part: fig5-75
## iProperties
Created: 2009-03
Part Number: fig5-75
Document SubType Name: Modeling
Designer: Sham
Density: 1 g/cm^3
Author: Sham
## Feature names
1. Extrusion3
